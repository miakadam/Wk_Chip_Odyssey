** sch_path: /foss/designs/testnetgen/nmos.sch
**.subckt nmos drain source gate
*.iopin drain
*.iopin source
*.iopin gate
XM9 drain gate source source nfet_03v3 L=1u W=3u nf=5 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)'
+ ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
**.ends
.end
