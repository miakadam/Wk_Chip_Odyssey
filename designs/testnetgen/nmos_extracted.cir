* Extracted by KLayout with GF180MCU LVS runset on : 07/09/2025 03:19

.SUBCKT nmos
M$1 \$1 \$3 \$2 gf180mcu_gnd nfet_03v3 L=1U W=3U AS=1.83P AD=0.78P PS=7.22U
+ PD=3.52U
M$2 \$2 \$3 \$1 gf180mcu_gnd nfet_03v3 L=1U W=3U AS=0.78P AD=0.78P PS=3.52U
+ PD=3.52U
M$3 \$1 \$3 \$2 gf180mcu_gnd nfet_03v3 L=1U W=3U AS=0.78P AD=0.78P PS=3.52U
+ PD=3.52U
M$4 \$2 \$3 \$1 gf180mcu_gnd nfet_03v3 L=1U W=3U AS=0.78P AD=0.78P PS=3.52U
+ PD=3.52U
M$5 \$1 \$3 \$2 gf180mcu_gnd nfet_03v3 L=1U W=3U AS=0.78P AD=1.83P PS=3.52U
+ PD=7.22U
.ENDS nmos
