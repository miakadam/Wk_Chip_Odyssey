v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -440 -450 -440 -380 {lab=A_VDD}
N -1070 -350 -480 -350 {lab=I_REF}
N -1110 -450 -1110 -380 {lab=A_VDD}
N -1110 -450 -440 -450 {lab=A_VDD}
N 280 -450 280 -380 {lab=A_VDD}
N -440 -450 140 -450 {lab=A_VDD}
N -310 -350 100 -350 {lab=I_REF}
N -310 -400 -310 -350 {lab=I_REF}
N -510 -400 -310 -400 {lab=I_REF}
N -510 -400 -510 -350 {lab=I_REF}
N -640 -120 -640 -40 {lab=#net1}
N -640 -120 -440 -120 {lab=#net1}
N -440 -210 -440 -120 {lab=#net1}
N -440 -120 -230 -120 {lab=#net1}
N -230 -110 -230 -40 {lab=#net1}
N -230 -120 -230 -110 {lab=#net1}
N -640 20 -640 270 {lab=#net2}
N -230 20 -230 270 {lab=cs}
N -600 300 -270 300 {lab=#net2}
N -570 250 -570 300 {lab=#net2}
N -640 250 -570 250 {lab=#net2}
N -640 330 -640 420 {lab=A_VSS}
N -230 330 -230 420 {lab=A_VSS}
N -640 420 -230 420 {lab=A_VSS}
N 280 -210 280 100 {lab=cd}
N -230 420 140 420 {lab=A_VSS}
N -300 250 -300 300 {lab=#net2}
N -300 250 -160 250 {lab=#net2}
N -160 250 -160 300 {lab=#net2}
N -160 300 410 300 {lab=#net2}
N 720 330 720 410 {lab=A_VSS}
N 280 420 590 420 {lab=A_VSS}
N 720 410 720 420 {lab=A_VSS}
N 720 -10 720 270 {lab=OUT}
N 280 -450 590 -450 {lab=A_VDD}
N 720 -340 720 -70 {lab=A_VDD}
N -780 -10 -680 -10 {lab=IN_N}
N -190 -10 -100 -10 {lab=IN_P}
N 150 90 180 90 {lab=#net3}
N 240 90 280 90 {lab=cd}
N 60 90 90 90 {lab=cs}
N -1040 -350 -1040 -280 {lab=I_REF}
N 720 100 800 100 {lab=OUT}
N -450 -480 -450 -450 {lab=A_VDD}
N -390 420 -390 440 {lab=A_VSS}
N 280 190 280 420 {lab=A_VSS}
N 280 100 280 130 {lab=cd}
N 60 90 60 160 {lab=cs}
N -660 300 -640 300 {lab=A_VSS}
N -660 300 -660 350 {lab=A_VSS}
N -660 350 -640 350 {lab=A_VSS}
N -230 300 -210 300 {lab=A_VSS}
N -210 300 -210 350 {lab=A_VSS}
N -230 350 -210 350 {lab=A_VSS}
N 280 160 300 160 {lab=A_VSS}
N 300 160 300 210 {lab=A_VSS}
N 280 210 300 210 {lab=A_VSS}
N 720 300 740 300 {lab=A_VSS}
N 740 300 740 350 {lab=A_VSS}
N 720 350 740 350 {lab=A_VSS}
N 720 -40 740 -40 {lab=vss}
N 280 -350 300 -350 {lab=A_VDD}
N 300 -400 300 -350 {lab=A_VDD}
N 280 -400 300 -400 {lab=A_VDD}
N -440 -350 -420 -350 {lab=A_VDD}
N -420 -390 -420 -350 {lab=A_VDD}
N -440 -390 -420 -390 {lab=A_VDD}
N -1130 -350 -1110 -350 {lab=A_VDD}
N -1130 -390 -1130 -350 {lab=A_VDD}
N -1130 -390 -1110 -390 {lab=A_VDD}
N -640 -10 -610 -10 {lab=A_VDD}
N -270 -10 -230 -10 {lab=A_VDD}
N -610 -10 -270 -10 {lab=A_VDD}
N 140 -450 280 -450 {lab=A_VDD}
N 100 -350 240 -350 {lab=I_REF}
N 590 -450 710 -450 {lab=A_VDD}
N 710 -450 720 -450 {lab=A_VDD}
N 550 -40 680 -40 {lab=cd}
N 410 300 680 300 {lab=#net2}
N 590 420 720 420 {lab=A_VSS}
N 140 420 280 420 {lab=A_VSS}
N 100 160 240 160 {lab=cs}
N -1110 -320 -1110 -270 {lab=I_REF}
N -440 -320 -440 -290 {lab=#net1}
N 280 -320 280 -270 {lab=cd}
N 300 -350 310 -350 {lab=A_VDD}
N 720 -450 720 -340 {lab=A_VDD}
N -1110 -270 -1110 -210 {lab=I_REF}
N -1110 -280 -1040 -280 {lab=I_REF}
N -440 -290 -440 -210 {lab=#net1}
N 280 -270 280 -210 {lab=cd}
N 60 160 100 160 {lab=cs}
N -230 160 60 160 {lab=cs}
N 280 -40 550 -40 {lab=cd}
N 120 30 120 70 {lab=A_VDD}
N -1070 20 -1000 20 {lab=A_VDD}
N -1070 80 -1000 80 {lab=IN_N}
N -1070 110 -1000 110 {lab=IN_P}
N -1070 50 -1000 50 {lab=A_VSS}
N -1070 140 -1000 140 {lab=I_REF}
N -1070 170 -1000 170 {lab=OUT}
C {symbols/pfet_03v3.sym} -460 -350 0 0 {name=MP_TAIL
L=2u
W=15u
nf=3
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -660 -10 0 0 {name=MP_DIFF_L
L=2u
W=10u
nf=2
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -210 -10 0 1 {name=MP_DIFF_R
L=2u
W=10u
nf=2
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 260 -350 0 0 {name=MP_CS_LOAD
L=2u
W=15u
nf=3
m=25
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -1090 -350 0 1 {name=MP_MIRROR
L=2u
W=15u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} -250 300 0 0 {name=MN_LOAD_R
L=2u
W=12u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} -620 300 0 1 {name=MN_LOAD_L
L=2u
W=12u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 260 160 0 0 {name=MN_CS
L=2u
W=20u
nf=10
m=11
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 700 -40 0 0 {name=MN_CD
L=2u
W=10u
nf=10
m=26
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 700 300 0 0 {name=MN_CD_LOAD
L=2u
W=12u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} -450 -480 3 1 {name=p18 sig_type=std_logic lab=A_VDD}
C {lab_pin.sym} -390 440 1 1 {name=p32 sig_type=std_logic lab=A_VSS}
C {lab_pin.sym} 740 -40 0 1 {name=p38 sig_type=std_logic lab=A_VSS}
C {lab_pin.sym} -100 -10 0 1 {name=p39 sig_type=std_logic lab=IN_P}
C {devices/ngspice_get_expr.sym} 410 -380 0 0 {name=r106 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_cs_load.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_cs_load.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 410 -350 0 0 {name=r107 node=v(@m.xmp_cs_load.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 410 -320 0 0 {name=r108 node=v(@m.xmp_cs_load.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 470 -380 0 0 {name=r109 node=i(@m.xmp_cs_load.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 470 -350 0 0 {name=r110 node=@m.xmp_cs_load.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 840 -60 0 0 {name=r111 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_cd.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_cd.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 840 -30 0 0 {name=r112 node=v(@m.xmn_cd.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 840 0 0 0 {name=r113 node=v(@m.xmn_cd.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 900 -60 0 0 {name=r114 node=i(@m.xmn_cd.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 900 -30 0 0 {name=r115 node=@m.xmn_cd.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 840 290 0 0 {name=r116 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_cd_load.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_cd_load.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 840 320 0 0 {name=r117 node=v(@m.xmn_cd_load.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 840 350 0 0 {name=r118 node=v(@m.xmn_cd_load.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 900 290 0 0 {name=r119 node=i(@m.xmn_cd_load.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 900 320 0 0 {name=r120 node=@m.xmn_cd_load.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 390 160 0 0 {name=r121 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_cs.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_cs.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 390 190 0 0 {name=r122 node=v(@m.xmn_cs.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 390 220 0 0 {name=r123 node=v(@m.xmn_cs.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 450 160 0 0 {name=r124 node=i(@m.xmn_cs.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 450 190 0 0 {name=r125 node=@m.xmn_cs.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} -130 350 0 0 {name=r126 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_load_r.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_load_r.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} -130 380 0 0 {name=r127 node=v(@m.xmn_load_r.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} -130 410 0 0 {name=r128 node=v(@m.xmn_load_r.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} -70 350 0 0 {name=r129 node=i(@m.xmn_load_r.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} -70 380 0 0 {name=r130 node=@m.xmn_load_r.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} -790 340 0 0 {name=r131 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_load_l.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_load_l.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} -790 370 0 0 {name=r132 node=v(@m.xmn_load_l.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} -790 400 0 0 {name=r133 node=v(@m.xmn_load_l.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} -730 340 0 0 {name=r134 node=i(@m.xmn_load_l.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} -730 370 0 0 {name=r135 node=@m.xmn_load_l.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} -340 50 0 0 {name=r136 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_diff_r.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_diff_r.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} -340 80 0 0 {name=r137 node=v(@m.xmp_diff_r.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} -340 110 0 0 {name=r138 node=v(@m.xmp_diff_r.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} -280 50 0 0 {name=r139 node=i(@m.xmp_diff_r.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} -280 80 0 0 {name=r140 node=@m.xmp_diff_r.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} -630 50 0 0 {name=r141 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_diff_l.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_diff_l.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} -630 80 0 0 {name=r142 node=v(@m.xmp_diff_l.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} -630 110 0 0 {name=r143 node=v(@m.xmp_diff_l.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} -570 50 0 0 {name=r144 node=i(@m.xmp_diff_l.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} -570 80 0 0 {name=r145 node=@m.xmp_diff_l.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} -570 -310 0 0 {name=r146 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_tail.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_tail.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} -510 -310 0 0 {name=r147 node=i(@m.xmp_tail.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} -1210 -410 0 0 {name=r151 node=i(@m.xmp_mirror.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} -1210 -380 0 0 {name=r152 node=@m.xmp_mirror.m0[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} -570 -270 0 0 {name=r153 node=v(@m.xmp_tail.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} -570 -240 0 0 {name=r154 node=v(@m.xmp_tail.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} -510 -270 0 0 {name=r155 node=@m.xmp_tail.m0[gm]
descr="gm="}
C {lab_pin.sym} -430 -10 2 1 {name=p43 sig_type=std_logic lab=A_VDD}
C {lab_pin.sym} -1110 -210 1 1 {name=p53 sig_type=std_logic lab=I_REF
}
C {lab_pin.sym} -80 160 2 1 {name=p55 sig_type=std_logic lab=cs}
C {lab_pin.sym} 370 -40 2 1 {name=p56 sig_type=std_logic lab=cd}
C {lab_pin.sym} -780 -10 2 1 {name=p66 sig_type=std_logic lab=IN_N}
C {lab_pin.sym} 800 100 0 1 {name=p1 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 120 30 3 1 {name=p6 sig_type=std_logic lab=A_VDD}
C {symbols/ppolyf_u_1k.sym} 120 90 1 0 {name=R2
W=20e-6
L=10e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 210 90 3 0 {name=C1
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=15}
C {iopin.sym} -1070 20 2 0 {name=p2 lab=A_VDD}
C {iopin.sym} -1070 80 2 0 {name=p3 lab=IN_N}
C {iopin.sym} -1070 110 2 0 {name=p4 lab=IN_P}
C {iopin.sym} -1070 50 2 0 {name=p5 lab=A_VSS}
C {iopin.sym} -1070 140 2 0 {name=p7 lab=I_REF}
C {iopin.sym} -1070 170 2 0 {name=p8 lab=OUT}
C {lab_pin.sym} -1000 80 0 1 {name=p9 sig_type=std_logic lab=IN_N}
C {lab_pin.sym} -1000 20 0 1 {name=p10 sig_type=std_logic lab=A_VDD}
C {lab_pin.sym} -1000 140 0 1 {name=p11 sig_type=std_logic lab=I_REF
}
C {lab_pin.sym} -1000 170 0 1 {name=p12 sig_type=std_logic lab=OUT}
C {lab_pin.sym} -1000 110 0 1 {name=p13 sig_type=std_logic lab=IN_P}
C {lab_pin.sym} -1000 50 0 1 {name=p14 sig_type=std_logic lab=A_VSS}
