v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1770 -1330 1770 -1260 {lab=A_VDD}
N 1140 -1230 1730 -1230 {lab=I_REF}
N 1100 -1330 1100 -1260 {lab=A_VDD}
N 1100 -1330 1770 -1330 {lab=A_VDD}
N 2490 -1330 2490 -1260 {lab=A_VDD}
N 1770 -1330 2350 -1330 {lab=A_VDD}
N 1900 -1230 2310 -1230 {lab=I_REF}
N 1900 -1280 1900 -1230 {lab=I_REF}
N 1700 -1280 1900 -1280 {lab=I_REF}
N 1700 -1280 1700 -1230 {lab=I_REF}
N 1570 -1000 1570 -920 {lab=#net1}
N 1570 -1000 1770 -1000 {lab=#net1}
N 1770 -1090 1770 -1000 {lab=#net1}
N 1770 -1000 1980 -1000 {lab=#net1}
N 1980 -990 1980 -920 {lab=#net1}
N 1980 -1000 1980 -990 {lab=#net1}
N 1570 -860 1570 -610 {lab=#net2}
N 1980 -860 1980 -610 {lab=cs}
N 1610 -580 1940 -580 {lab=#net2}
N 1640 -630 1640 -580 {lab=#net2}
N 1570 -630 1640 -630 {lab=#net2}
N 1570 -550 1570 -460 {lab=A_VSS}
N 1980 -550 1980 -460 {lab=A_VSS}
N 1570 -460 1980 -460 {lab=A_VSS}
N 2490 -1090 2490 -780 {lab=cd}
N 1980 -460 2350 -460 {lab=A_VSS}
N 1910 -630 1910 -580 {lab=#net2}
N 1910 -630 2050 -630 {lab=#net2}
N 2050 -630 2050 -580 {lab=#net2}
N 2050 -580 2620 -580 {lab=#net2}
N 2930 -550 2930 -470 {lab=A_VSS}
N 2490 -460 2800 -460 {lab=A_VSS}
N 2930 -470 2930 -460 {lab=A_VSS}
N 2930 -890 2930 -610 {lab=OUT}
N 2490 -1330 2800 -1330 {lab=A_VDD}
N 2930 -1220 2930 -950 {lab=A_VDD}
N 1430 -890 1530 -890 {lab=IN_N}
N 2020 -890 2110 -890 {lab=IN_P}
N 2360 -790 2390 -790 {lab=#net3}
N 2450 -790 2490 -790 {lab=cd}
N 2270 -790 2300 -790 {lab=cs}
N 1170 -1230 1170 -1160 {lab=I_REF}
N 2930 -780 3010 -780 {lab=OUT}
N 1760 -1360 1760 -1330 {lab=A_VDD}
N 1820 -460 1820 -440 {lab=A_VSS}
N 2490 -690 2490 -460 {lab=A_VSS}
N 2490 -780 2490 -750 {lab=cd}
N 2270 -790 2270 -720 {lab=cs}
N 1550 -580 1570 -580 {lab=A_VSS}
N 1550 -580 1550 -530 {lab=A_VSS}
N 1550 -530 1570 -530 {lab=A_VSS}
N 1980 -580 2000 -580 {lab=A_VSS}
N 2000 -580 2000 -530 {lab=A_VSS}
N 1980 -530 2000 -530 {lab=A_VSS}
N 2490 -720 2510 -720 {lab=A_VSS}
N 2510 -720 2510 -670 {lab=A_VSS}
N 2490 -670 2510 -670 {lab=A_VSS}
N 2930 -580 2950 -580 {lab=A_VSS}
N 2950 -580 2950 -530 {lab=A_VSS}
N 2930 -530 2950 -530 {lab=A_VSS}
N 2930 -920 2950 -920 {lab=vss}
N 2490 -1230 2510 -1230 {lab=A_VDD}
N 2510 -1280 2510 -1230 {lab=A_VDD}
N 2490 -1280 2510 -1280 {lab=A_VDD}
N 1770 -1230 1790 -1230 {lab=A_VDD}
N 1790 -1270 1790 -1230 {lab=A_VDD}
N 1770 -1270 1790 -1270 {lab=A_VDD}
N 1080 -1230 1100 -1230 {lab=A_VDD}
N 1080 -1270 1080 -1230 {lab=A_VDD}
N 1080 -1270 1100 -1270 {lab=A_VDD}
N 1570 -890 1600 -890 {lab=A_VDD}
N 1940 -890 1980 -890 {lab=A_VDD}
N 1600 -890 1940 -890 {lab=A_VDD}
N 2350 -1330 2490 -1330 {lab=A_VDD}
N 2310 -1230 2450 -1230 {lab=I_REF}
N 2800 -1330 2920 -1330 {lab=A_VDD}
N 2920 -1330 2930 -1330 {lab=A_VDD}
N 2760 -920 2890 -920 {lab=cd}
N 2620 -580 2890 -580 {lab=#net2}
N 2800 -460 2930 -460 {lab=A_VSS}
N 2350 -460 2490 -460 {lab=A_VSS}
N 2310 -720 2450 -720 {lab=cs}
N 1100 -1200 1100 -1150 {lab=I_REF}
N 1770 -1200 1770 -1170 {lab=#net1}
N 2490 -1200 2490 -1150 {lab=cd}
N 2510 -1230 2520 -1230 {lab=A_VDD}
N 2930 -1330 2930 -1220 {lab=A_VDD}
N 1100 -1150 1100 -1090 {lab=I_REF}
N 1100 -1160 1170 -1160 {lab=I_REF}
N 1770 -1170 1770 -1090 {lab=#net1}
N 2490 -1150 2490 -1090 {lab=cd}
N 2270 -720 2310 -720 {lab=cs}
N 1980 -720 2270 -720 {lab=cs}
N 2490 -920 2760 -920 {lab=cd}
N 2330 -850 2330 -810 {lab=A_VDD}
N 1140 -860 1210 -860 {lab=A_VDD}
N 1140 -800 1210 -800 {lab=IN_N}
N 1140 -770 1210 -770 {lab=IN_P}
N 1140 -830 1210 -830 {lab=A_VSS}
N 1140 -740 1210 -740 {lab=I_REF}
N 1140 -710 1210 -710 {lab=OUT}
C {symbols/pfet_03v3.sym} 1750 -1230 0 0 {name=MP_TAIL
L=2u
W=15u
nf=3
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1550 -890 0 0 {name=MP_DIFF_L
L=2u
W=10u
nf=2
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2000 -890 0 1 {name=MP_DIFF_R
L=2u
W=10u
nf=2
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2470 -1230 0 0 {name=MP_CS_LOAD
L=2u
W=15u
nf=3
m=25
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1120 -1230 0 1 {name=MP_MIRROR
L=2u
W=15u
nf=3
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1960 -580 0 0 {name=MN_LOAD_R
L=2u
W=12u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 -580 0 1 {name=MN_LOAD_L
L=2u
W=12u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2470 -720 0 0 {name=MN_CS
L=2u
W=20u
nf=10
m=11
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2910 -920 0 0 {name=MN_CD
L=2u
W=10u
nf=10
m=26
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2910 -580 0 0 {name=MN_CD_LOAD
L=2u
W=12u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 1760 -1360 3 1 {name=p18 sig_type=std_logic lab=A_VDD}
C {lab_pin.sym} 1820 -440 1 1 {name=p32 sig_type=std_logic lab=A_VSS}
C {lab_pin.sym} 2950 -920 0 1 {name=p38 sig_type=std_logic lab=A_VSS}
C {lab_pin.sym} 2110 -890 0 1 {name=p39 sig_type=std_logic lab=IN_P}
C {devices/ngspice_get_expr.sym} 2620 -1260 0 0 {name=r106 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_cs_load.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_cs_load.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 2620 -1230 0 0 {name=r107 node=v(@m.xmp_cs_load.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 2620 -1200 0 0 {name=r108 node=v(@m.xmp_cs_load.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 2680 -1260 0 0 {name=r109 node=i(@m.xmp_cs_load.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 2680 -1230 0 0 {name=r110 node=@m.xmp_cs_load.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 3050 -940 0 0 {name=r111 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_cd.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_cd.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 3050 -910 0 0 {name=r112 node=v(@m.xmn_cd.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 3050 -880 0 0 {name=r113 node=v(@m.xmn_cd.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 3110 -940 0 0 {name=r114 node=i(@m.xmn_cd.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 3110 -910 0 0 {name=r115 node=@m.xmn_cd.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 3050 -590 0 0 {name=r116 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_cd_load.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_cd_load.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 3050 -560 0 0 {name=r117 node=v(@m.xmn_cd_load.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 3050 -530 0 0 {name=r118 node=v(@m.xmn_cd_load.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 3110 -590 0 0 {name=r119 node=i(@m.xmn_cd_load.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 3110 -560 0 0 {name=r120 node=@m.xmn_cd_load.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 2600 -720 0 0 {name=r121 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_cs.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_cs.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 2600 -690 0 0 {name=r122 node=v(@m.xmn_cs.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 2600 -660 0 0 {name=r123 node=v(@m.xmn_cs.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 2660 -720 0 0 {name=r124 node=i(@m.xmn_cs.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 2660 -690 0 0 {name=r125 node=@m.xmn_cs.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 2080 -530 0 0 {name=r126 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_load_r.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_load_r.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 2080 -500 0 0 {name=r127 node=v(@m.xmn_load_r.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 2080 -470 0 0 {name=r128 node=v(@m.xmn_load_r.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 2140 -530 0 0 {name=r129 node=i(@m.xmn_load_r.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 2140 -500 0 0 {name=r130 node=@m.xmn_load_r.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 1420 -540 0 0 {name=r131 
node="[format %.4g [expr [ngspice::get_node \{@m.xmn_load_l.m0[gm]\}] / [ngspice::get_node \{i(@m.xmn_load_l.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 1420 -510 0 0 {name=r132 node=v(@m.xmn_load_l.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 1420 -480 0 0 {name=r133 node=v(@m.xmn_load_l.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 1480 -540 0 0 {name=r134 node=i(@m.xmn_load_l.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 1480 -510 0 0 {name=r135 node=@m.xmn_load_l.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 1870 -830 0 0 {name=r136 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_diff_r.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_diff_r.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 1870 -800 0 0 {name=r137 node=v(@m.xmp_diff_r.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 1870 -770 0 0 {name=r138 node=v(@m.xmp_diff_r.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 1930 -830 0 0 {name=r139 node=i(@m.xmp_diff_r.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 1930 -800 0 0 {name=r140 node=@m.xmp_diff_r.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 1580 -830 0 0 {name=r141 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_diff_l.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_diff_l.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 1580 -800 0 0 {name=r142 node=v(@m.xmp_diff_l.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 1580 -770 0 0 {name=r143 node=v(@m.xmp_diff_l.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 1640 -830 0 0 {name=r144 node=i(@m.xmp_diff_l.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 1640 -800 0 0 {name=r145 node=@m.xmp_diff_l.m0[gm]
descr="gm="}
C {devices/ngspice_get_expr.sym} 1640 -1190 0 0 {name=r146 
node="[format %.4g [expr [ngspice::get_node \{@m.xmp_tail.m0[gm]\}] / [ngspice::get_node \{i(@m.xmp_tail.m0[id])\}]]]"
descr="gm/ID="}
C {devices/ngspice_get_value.sym} 1700 -1190 0 0 {name=r147 node=i(@m.xmp_tail.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 1000 -1290 0 0 {name=r151 node=i(@m.xmp_mirror.m0[id])
descr="id="}
C {devices/ngspice_get_value.sym} 1000 -1260 0 0 {name=r152 node=@m.xmp_mirror.m0[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 1640 -1150 0 0 {name=r153 node=v(@m.xmp_tail.m0[vdsat])
descr="vdsat="}
C {devices/ngspice_get_value.sym} 1640 -1120 0 0 {name=r154 node=v(@m.xmp_tail.m0[vds])
descr="vds="}
C {devices/ngspice_get_value.sym} 1700 -1150 0 0 {name=r155 node=@m.xmp_tail.m0[gm]
descr="gm="}
C {lab_pin.sym} 1780 -890 2 1 {name=p43 sig_type=std_logic lab=A_VDD}
C {lab_pin.sym} 1100 -1090 1 1 {name=p53 sig_type=std_logic lab=I_REF
}
C {lab_pin.sym} 2130 -720 2 1 {name=p55 sig_type=std_logic lab=cs}
C {lab_pin.sym} 2580 -920 2 1 {name=p56 sig_type=std_logic lab=cd}
C {lab_pin.sym} 1430 -890 2 1 {name=p66 sig_type=std_logic lab=IN_N}
C {lab_pin.sym} 3010 -780 0 1 {name=p1 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 2330 -850 3 1 {name=p6 sig_type=std_logic lab=A_VDD}
C {symbols/ppolyf_u_1k.sym} 2330 -790 1 0 {name=R2
W=20e-6
L=10e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 2420 -790 3 0 {name=C1
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=15}
C {iopin.sym} 1140 -860 2 0 {name=p2 lab=A_VDD}
C {iopin.sym} 1140 -800 2 0 {name=p3 lab=IN_N}
C {iopin.sym} 1140 -770 2 0 {name=p4 lab=IN_P}
C {iopin.sym} 1140 -830 2 0 {name=p5 lab=A_VSS}
C {iopin.sym} 1140 -740 2 0 {name=p7 lab=I_REF}
C {iopin.sym} 1140 -710 2 0 {name=p8 lab=OUT}
C {lab_pin.sym} 1210 -800 0 1 {name=p9 sig_type=std_logic lab=IN_N}
C {lab_pin.sym} 1210 -860 0 1 {name=p10 sig_type=std_logic lab=A_VDD}
C {lab_pin.sym} 1210 -740 0 1 {name=p11 sig_type=std_logic lab=I_REF
}
C {lab_pin.sym} 1210 -710 0 1 {name=p12 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 1210 -770 0 1 {name=p13 sig_type=std_logic lab=IN_P}
C {lab_pin.sym} 1210 -830 0 1 {name=p14 sig_type=std_logic lab=A_VSS}
