v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {git/Wk_Chip_Odyssey/designs/TIA/CORE_TIA.sym} 0 0 0 0 {name=x1}
